# Keil uVision project STM32F429.uvprojx, settings and files
target bootloader (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F429
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c include: ..\core;..\device;..\HAL_LIB\STM32F4xx_HAL_Driver\Inc\Legacy;..\HAL_LIB\STM32F4xx_HAL_Driver\Inc;..\user
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group user
    ../user/: main.c stm32f4xx_it.c system_stm32f4xx.c
  group device
    ../device/: delay.c led.c sys.c usart.c flash.c bootloader.c tim.c i2c.c
  group HAL_LIB
    ../HAL_LIB/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c
  group core
    ../core/: startup_stm32f429xx.s
