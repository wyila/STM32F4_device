# Keil uVision project STM32F429.uvprojx, settings and files
target APP (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F429
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F429xx
  c include: ..\core;..\device;..\user
  memory RVCT4: ROM 0x8008000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group user
    ../user/: main.c sys.c
  group device
    ../device/: delay.c led.c tim.c usart.c i2c.c iap.c ble.c spi.c sdram.c w25qxx.c cmd.c
  group core
    ../core/: startup_stm32f429xx.s system_stm32f4xx.c
  group README
    ../: README.md
